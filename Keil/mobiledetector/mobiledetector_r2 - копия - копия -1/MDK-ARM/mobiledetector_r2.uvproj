# Keil uVision project mobiledetector_r2.uvproj, settings and files
target mobiledetector_r2 (ARM-ADS)
  device: STM32L152C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mobiledetector_r2
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xB
  c misc: --C99
  c include: ../Inc;       ../Drivers/STM32L1xx_HAL_Driver/Inc;       ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;       ../Drivers/CMSIS/Include;     ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;     ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_flash.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_rcc.c stm32l1xx_hal_tim.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_dma.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pcd.c stm32l1xx_hal_adc_ex.c
  group Application/User
    ../Src/: stm32l1xx_it.c tim.c adc.c stm32l1xx_hal_msp.c i2c.c usart.c gpio.c main.c iwdg.c crc16.c mb.c mb_slave.c modbus_config.c usb_device.c usbd_desc.c usbd_conf.c usbd_cdc_if.c
  group Application/MDK-ARM
    ./: startup_stm32l152xb.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
