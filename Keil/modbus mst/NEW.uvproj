# Keil uVision project NEW.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: NEW +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\sip_keil\lpc17xx_lib\include;..\sip_keil\lpc17xx_lib\cmsis;..\sip_keil\lpc17xx_lib\cmsis_boot;..\sip_keil\v6.3_SP020105\lpc1700;..\sip_keil\v6.3_SP020105\pid;..\sip_keil\MD5;..\sip_keil\C_lib\utils;..\sip_keil\v6.3_SP020105\modbus;..\sip_keil\sip_common;..\new_project;.\freemodbus\modbus\rtu;.\freemodbus\modbus;.\freemodbus\modbus\include;.\freemodbus\lpc1768\port;.\freemodbus\modbus\ascii
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../sip_keil/lpc17xx_lib/cmsis_boot/: LPC17xx.h
    ./: startup_LPC17xx.s
  group src
    ./: main.c system_LPC17xx.c
  group std_lib
    ../sip_keil/lpc17xx_lib/source/: lpc17xx_clkpwr.c lpc17xx_uart.c lpc17xx_libcfg_default.c lpc17xx_ssp.c lpc17xx_adc.c lpc17xx_systick.c lpc17xx_gpio.c lpc17xx_pinsel.c lpc17xx_timer.c
    ../sip_keil/lpc17xx_lib/include/: lpc17xx_uart.h lpc17xx_adc.h lpc17xx_systick.h lpc17xx_pinsel.h lpc17xx_gpio.h lpc17xx_timer.h
  group mb_mst
    ./: modbs_master.c modbs_master.h
